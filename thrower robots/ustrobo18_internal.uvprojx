# Keil uVision project ustrobo18_internal.uvprojx, settings and files
target Default (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ustrobo18_internal +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_ML
  c include: .\src\stm32f10x_std\inc;.\src\library;.\src\user
  asm include: .\src\stm32f10x_startup;.\src\stm32f10x_std;.\src\library;.\src\user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group stm32f10x_startup
    ./src/stm32f10x_startup/: startup_stm32f10x_md.s
  group stm32f10x_std
    ./src/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group library
    ./src/library/: ticks.c pwm.c gpio.c leds.c buttons.c buzzer.c uart.c spi.c lcd_main.c camera.c adc.c rcc.c oled.c lineTracker.c Sonar.c delay.c
  group user
    ./src/user/: main.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
